# IAR project MM32F3277.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DEVICE
  ICCARM.CCDiagSuppress: pa082
  ICCARM.CCIncludePath2: D:\双车代码\电赛真B\Project\CODE; D:\双车代码\电赛真B\Project\USER\inc; D:\双车代码\电赛真B\Project\USER\src; D:\双车代码\电赛真B\Libraries\Device\CMSIS\IAR_Core; D:\双车代码\电赛真B\Libraries\Device\MM32F327x\Include; D:\双车代码\电赛真B\Libraries\Device\MM32F327x\HAL_Lib\Inc; D:\双车代码\电赛真B\Libraries\seekfree_libraries; D:\双车代码\电赛真B\Libraries\seekfree_libraries\board; D:\双车代码\电赛真B\Libraries\seekfree_libraries\common; ..\..\..\..\..\MM32F3277_Library\Seekfree_MM32F3277_Opensource_Library\Libraries\seekfree_peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MM32F3277.srec
  ILINK.IlinkOutputFile: MM32F3277.out
  ILINK.IlinkIcfFile: MM32F3270.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\CODE; ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\Device\CMSIS\IAR_Core; ..\..\..\Libraries\Device\MM32F327x\Include; ..\..\..\Libraries\Device\MM32F327x\HAL_Lib\Inc; ..\..\..\Libraries\seekfree_libraries; ..\..\..\Libraries\seekfree_libraries\board; ..\..\..\Libraries\seekfree_libraries\common; ..\..\..\Libraries\seekfree_peripheral
  ICCARM.CCOptLevel: 3
  group board
    ../../../Libraries/seekfree_libraries/board/: board.c board.h
  group code
    ../../CODE/: Control.c Control.h FUZZ.c FUZZ.h MENU.c MENU.h Picture.c Picture.h 本文件夹作用.txt
  group common
    ../../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group doc
    ../../../Libraries/doc/: pin_recommend.txt version.txt
  group mm32_hal
    ../../../Libraries/Device/MM32F327x/HAL_Lib/Inc/: dtype.h hal_adc.h hal_bkp.h hal_can.h hal_comp.h hal_conf.h hal_crc.h hal_crs.h hal_dac.h hal_dbg.h hal_device.h hal_dma.h hal_eth.h HAL_eth_conf.h hal_exti.h hal_flash.h hal_fsmc.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_redefine.h hal_rtc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../../../Libraries/Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group seekfree_libraries
    ../../../Libraries/seekfree_libraries/: headfile.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_fsmc.c zf_fsmc.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_libraries/seekfree_peripheral
    ../../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_UART_7725.c SEEKFREE_UART_7725.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group startup
    ../../../Libraries/Device/MM32F327x/Source/IAR_StartAsm/: startup_mm32f327x_iar.s
    ../../../Libraries/Device/MM32F327x/Source/: system_mm32f327x.c
  group user_c
    ../../USER/src/: isr.c main.c
  group user_h
    ../../USER/inc/: isr.h
